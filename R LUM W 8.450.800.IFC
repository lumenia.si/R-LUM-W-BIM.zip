Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: R LUM W 8.450.800.IFC
Time: 2023-12-07T11:24:11
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: R LUM W 8.450.800
In: Default Storey
SolidWorks Custom Properties - Description: R LUM W 8.450.800
PSet_Mass_Property - Mass Measure: 2.01698; Area Measure: 0.133001 m2; Volume Measure: 0.00201698 m3
