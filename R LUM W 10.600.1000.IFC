Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ml15-1_simplified.IFC
Time: 2023-07-27T09:21:50
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: ml15-1_simplified
In: Default Storey
SolidWorks Custom Properties - Description: PWR(8-10W);LUM.FLUX(800-1000lm);TEMP(3000,4000,5000K); IP44
